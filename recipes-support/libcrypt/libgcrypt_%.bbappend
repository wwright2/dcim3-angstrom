EXTRA_OECONF = " --disable-asm  \ 
	--with-capabilities \
	CFLAGS=-I${STAGING_INCDIR} \
	"