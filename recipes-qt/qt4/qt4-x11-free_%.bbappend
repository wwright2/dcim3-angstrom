
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

QT_CONFIG_FLAGS += " \
 -qt-gfx-transformed	\
 "


