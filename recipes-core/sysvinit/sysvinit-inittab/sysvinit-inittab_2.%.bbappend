FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://inittab;name=inittab"
