
#EXTRA_OECONF =+ " --disable-su --disable-sulogin \
#"
PACKAGECONFIG[pam] = " --disable-su --disable-sulogin "
