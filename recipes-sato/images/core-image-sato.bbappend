

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

DISTRO_FEATURES =+ " x11 "
