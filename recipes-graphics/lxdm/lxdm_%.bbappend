EXTRA_OECONF += "	\
					--disable-pam	\
"