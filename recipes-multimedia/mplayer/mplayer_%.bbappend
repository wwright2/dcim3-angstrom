


PREFERRED_VERSION = "1.0"
PNBLACKLIST[mplayer] =""

DEPENDS += "libxscrnsaver libdvdnav"

SRC_URI = "git://github.com/wwright2/mplayer.git "
SRCREV = "1fa9b44114b9517c4cbebabf57eb135fc1487d9d"